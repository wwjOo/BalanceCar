# Keil uVision project RC.uvprojx, settings and files
target RC (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RC +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\FWLib\inc;..\FWLib;..\OtherC;..\USER;..\OtherC\adc;..\OtherC\delay;..\OtherC\usart;..\OtherC\timer;..\OtherC\key;..\OtherC\data_count;..\OtherC\led
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group USER
    ../USER/: main.c stm32f10x_it.c
  group OtherC
    ../OtherC/: includes.h
    ../OtherC/delay/: delay.c
    ../OtherC/usart/: usart.c
    ../OtherC/adc/: adc.c
    ../OtherC/timer/: timer.c
    ../OtherC/key/: key.c
    ../OtherC/led/: led.c
    ../OtherC/data_count/: data_count.c
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_adc.c
