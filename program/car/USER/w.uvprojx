# Keil uVision project w.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: QF +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\core;..\user;..\fwlib\inc;..\system\delay;..\system\sys;..\system\usart;..\HARDWARE;..\9-Axis
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group core
    ../core/: startup_stm32f40_41xxx.s core_cm4.h
  group user
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group hardware
    ../HARDWARE/: systick.c oled.c usart1.c motor.c encode.c adc.c Power.c car_ctrl.c stmflash.c Scheduler.c
    ../hardware/: led.c
  group 9Axis
    ../9-Axis/: spi.c ak8975.c icm20602.c DataCal.c imu.c MagProcess.c structural.c
  group system
    ../system/sys/: sys.c
  group fwlib
    ../fwlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../FWLIB/src/: stm32f4xx_dcmi.c
